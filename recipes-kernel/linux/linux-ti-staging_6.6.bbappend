FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0003-Add-overlay-to-support-Digilent-ov5640-camera.patch file://0004-Enable-support-for-ADC081C.patch file://0001-Add-Device-Tree-support-for-OSD62-PM-BRK.patch file://0005-Enable-gpio-sysfs-support.patch file://0002-Add-overlay-to-support-microtips-mf101hie-panel.patch"

